# Keil uVision project bb-qk.uvprojx, settings and files
target bb-dbg (6160000::V6.16::ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: bb-qk
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\bb-qk.bin .\dbg\bb-qk.axf
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: QK_USE_IRQ_HANDLER=WWDG_IRQHandler QK_USE_IRQ_NUM=0
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qk\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-l053r8
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.c main.c
    ../../: bsp.h blinky_button.h blinky1.c blinky3.c button2a.c button2b.c
    ../../../../../src/qs/: qstamp.c
  group nucleo-l053r8
    ../../../../../3rd_party/nucleo-l053r8/: stm32l0xx.h stm32l053xx.h system_stm32l0xx.c system_stm32l0xx.h
    ../../../../../3rd_party/nucleo-l053r8/arm/: startup_stm32l053xx.s
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qk/: qk.c
  group QP_port
    ../../../../../ports/arm-cm/qk/armclang/: qep_port.h qf_port.h qk_port.h qs_port.h qk_port.c
  group QS
    ../../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c
target bb-rel (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: as above
  output: bb-qk
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\bb-qk.bin .\rel\bb-qk.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
target bb-spy (6160000::V6.16::ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: as above
  output: bb-qk
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\bb-qk.bin .\spy\bb-qk.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY QK_USE_IRQ_HANDLER=LCD_IRQHandler QK_USE_IRQ_NUM=30
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
