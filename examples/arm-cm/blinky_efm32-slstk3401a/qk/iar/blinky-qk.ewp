# IAR project blinky-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFM32PG1B200F256GM48
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\arm-cm\qk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\efm32pg1b
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: blinky-qk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: blinky-qk.out
  ILINK.IlinkIcfFile: blinky-qk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG1B200F256GM48
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; EFM32PG1B200F256GM48
  group Application
    ../../: blinky.c blinky.h bsp.h main.c
    ../: bsp.c
    ../../../../../include/: qstamp.c
  group efm32pg1b
    ../../../../../3rd_party/efm32pg1b/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_system.c system_efm32pg1b.c
    ../../../../../3rd_party/efm32pg1b/iar/: startup_efm32pg1b.s
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/: qf_pkg.h qk_pkg.h
    ../../../../../src/qk/: qk.c qk_mutex.c
  group QP_port
    ../../../../../ports/arm-cm/qk/iar/: qk_port.s
  group QS
    ../../../../../src/qs/: qs.c qs_fp.c qs_rx.c
    ../../../../../src/: qs_pkg.h
