# Keil uVision project blinky-qv.uvprojx, settings and files
target blinky-dbg (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: Keil.EFM32PG1B_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky-qv
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\blinky-qv.bin .\dbg\blinky-qv.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\src;..\..\..\..\..\ports\arm-cm\qv\arm;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\efm32pg1b
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.c
    ../../: blinky.c main.c blinky.h
    ../../../../../include/: qstamp.c
  group efm32pg1b
    ../../../../../3rd_party/efm32pg1b/arm/: startup_efm32pg1b.s
    ../../../../../3rd_party/efm32pg1b/: em_cmu.c em_emu.c em_gpio.c em_int.c em_rtcc.c em_system.c system_efm32pg1b.c
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qv/: qv.c
  group QP_port
    ../../../../../ports/arm-cm/qv/arm/: qv_port.c
  group QS
    ../../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c
target blinky-rel (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: Keil.EFM32PG1B_DFP.1.0.0
  cpu: as above
  output: blinky-qv
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\blinky-qv.bin .\rel\blinky-qv.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
target blinky-spy (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: Keil.EFM32PG1B_DFP.1.0.0
  cpu: as above
  output: blinky-qv
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\blinky-qv.bin .\spy\blinky-qv.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: Q_SPY EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
