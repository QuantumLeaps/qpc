# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: QP_CONFIG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..\..\..; ..\..\..\..\..\..\3rd_party\efm32pg1b; ..\..\..\..\..\..\3rd_party\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; QP_CONFIG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; QP_CONFIG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  group Application
    ../../: bsp.c
    ../../../: bsp.h dpp.h main.c philo.c table.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/QuantumLeaps Quantum Leaps QP_C _RTEF.Software tracing.qs_7.3.0
    ${CMSIS_PACK_PATH_QuantumLeaps#qpc#7.3.0}$/src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qstamp.c qutest.c
  group CMSIS-Pack/QuantumLeaps Quantum Leaps QP_C _RTEF.Real-Time Kernel.qk_7.3.0
    ${CMSIS_PACK_PATH_QuantumLeaps#qpc#7.3.0}$/src/qf/: qf_actq.c
    ${CMSIS_PACK_PATH_QuantumLeaps#qpc#7.3.0}$/src/qk/: qk.c
    ${CMSIS_PACK_PATH_QuantumLeaps#qpc#7.3.0}$/ports/arm-cm/qk/iar/: qk_port.c
    RTE/RTEF/: qp_config.h
  group CMSIS-Pack/QuantumLeaps Quantum Leaps QP_C _RTEF.Framework.qf_7.3.0
    ${CMSIS_PACK_PATH_QuantumLeaps#qpc#7.3.0}$/src/qf/: qf_act.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
  group CMSIS-Pack/QuantumLeaps Quantum Leaps QP_C _RTEF.Event Processor.qep_7.3.0
    ${CMSIS_PACK_PATH_QuantumLeaps#qpc#7.3.0}$/src/qf/: qep_hsm.c qep_msm.c
  group efm32pg1b
    ../../../../../../3rd_party/efm32pg1b/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_system.c em_usart.c system_efm32pg1b.c
    ../../../../../../3rd_party/efm32pg1b/iar/: startup_efm32pg1b.s
