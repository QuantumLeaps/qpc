# Keil uVision project dpp-qxk.uvprojx, settings and files
target dpp-dbg (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dpp-qxk
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp-qxk.bin .\dbg\dpp-qxk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __FPU_PRESENT
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\src;..\..\..\..\..\ports\arm-cm\qxk\arm;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.c main.c test.c
    ../../: dpp.h bsp.h philo.c table.c
    ../../../../../include/: qstamp.c
  group ek-tm4c123gxl
    ../../../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h gpio.h rom.h sysctl.h system_TM4C123GH6PM.h
    ../../../../../3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
  group QP_port
    ../../../../../ports/arm-cm/qxk/arm/: qxk_port.s
  group QS
    ../../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c
target dpp-rel (5060020::V5.06 (build 20)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: dpp-qxk
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp-qxk.bin .\rel\dpp-qxk.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
target dpp-spy (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: dpp-qxk
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp-qxk.bin .\spy\dpp-qxk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
