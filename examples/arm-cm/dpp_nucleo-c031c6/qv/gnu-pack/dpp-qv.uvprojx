# Keil uVision project dpp-qv.uvprojx, settings and files
target dpp-dbg (6190000::V6.19::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: dpp-qv +hex
  AfterMake: objcopy --input-target=ihex --output-target=binary !H $H@P.bin
  group Source Code
    ../: bsp.c
    ../../: bsp.h dpp.h philo.c table.c main.c
  group nucleo-c031c6
    ../../../../../3rd_party/nucleo-c031c6/: stm32c0xx.h stm32c031xx.h system_stm32c0xx.c
    ../../../../../3rd_party/nucleo-c031c6/gnu/: startup_stm32c031xx.c
target dpp-rel (6190000::V6.19::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: dpp-qv
  AfterMake: as above
target dpp-spy (6190000::V6.19::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: dpp-qv
software components: RTEF:Event Processor 7.3.0, RTEF:Framework 7.3.0, RTEF:Real-Time Kernel 7.3.0, RTEF:Software tracing 7.3.0
