# Keil uVision project dpp-qk.uvprojx, settings and files
target dpp-dbg (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: dpp-qk
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp-qk.bin .\dbg\dpp-qk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\source;..\..\..\..\..\ports\arm-cm\qk\arm;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-l053r8
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.c
    ../../: bsp.h dpp.h main.c philo.c table.c
    ../../../../../include/: qstamp.c
  group nucleo-l053r8
    ../../../../../3rd_party/nucleo-l053r8/: stm32l0xx.h stm32l053xx.h system_stm32l0xx.c system_stm32l0xx.h
    ../../../../../3rd_party/nucleo-l053r8/arm/: startup_stm32l053xx.s
  group QP
    ../../../../../source/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_pkg.h qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c qk.c qk_mutex.c qk_pkg.h
  group QP_port
    ../../../../../ports/arm-cm/qk/arm/: qep_port.h qf_port.h qk_port.h qk_port.s qs_port.h
  group QS
    ../../../../../source/: qs.c qs_64bit.c qs_fp.c qs_pkg.h
target dpp-rel (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: as above
  output: dpp-qk
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp-qk.bin .\rel\dpp-qk.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
target dpp-spy (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: as above
  output: dpp-qk
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp-qk.bin .\spy\dpp-qk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
