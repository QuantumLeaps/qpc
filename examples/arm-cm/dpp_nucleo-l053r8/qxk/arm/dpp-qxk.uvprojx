# Keil uVision project dpp-qxk.uvprojx, settings and files
target dpp-dbg (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: dpp-qxk
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp-qxk.bin .\dbg\dpp-qxk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\src;..\..\..\..\..\ports\arm-cm\qxk\arm;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-l053r8
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.c main.c test.c
    ../../: bsp.h dpp.h philo.c table.c
    ../../../../../include/: qstamp.c
  group nucleo-l053r8
    ../../../../../3rd_party/nucleo-l053r8/: stm32l0xx.h stm32l053xx.h system_stm32l0xx.c system_stm32l0xx.h
    ../../../../../3rd_party/nucleo-l053r8/arm/: startup_stm32l053xx.s
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/: qf_pkg.h qxk_pkg.h
    ../../../../../src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
  group QP_port
    ../../../../../ports/arm-cm/qxk/arm/: qep_port.h qf_port.h qxk_port.h qxk_port.s qs_port.h
  group QS
    ../../../../../src/qs/: qs.c qs_64bit.c qs_fp.c
    ../../../../../src/: qs_pkg.h
target dpp-rel (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: dpp-qxk
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp-qxk.bin .\rel\dpp-qxk.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
target dpp-spy (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: dpp-qxk
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp-qxk.bin .\spy\dpp-qxk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
