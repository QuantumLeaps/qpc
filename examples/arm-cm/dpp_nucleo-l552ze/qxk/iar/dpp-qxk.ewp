# IAR project dpp-qxk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562ZE ST STM32L562ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L552xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm-cm\qxk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\STM32CubeL5\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\3rd_party\STM32CubeL5\Drivers/STM32L5xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\3rd_party\STM32CubeL5\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\3rd_party\STM32CubeL5\Drivers\BSP\STM32L5xx_Nucleo
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qxk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-qxk.out
  ILINK.IlinkIcfFile: dpp-qxk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  ICCARM.CCDefines: NDEBUG; USE_HAL_DRIVER; STM32L552xx
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  ICCARM.CCDefines: Q_SPY; USE_HAL_DRIVER; STM32L552xx
  group Application
    ../: bsp.c main.c test.c
    ../../: bsp.h dpp.h philo.c table.c
    ../../../../../include/: qstamp.c
  group nucleo-l552ze
    ../../../../../3rd_party/STM32CubeL5/nucleo-l552ze/iar/: startup_stm32l552xx.s
    ../../: stm32l5xx_hal_conf.h stm32l5xx_hal_msp.c stm32l5xx_nucleo_conf.h
    ../../../../../3rd_party/STM32CubeL5/Drivers/BSP/STM32L5xx_Nucleo/: stm32l5xx_nucleo.c
    ../../../../../3rd_party/STM32CubeL5/Drivers/CMSIS/Device/ST/STM32L5xx/Source/Templates/: system_stm32l5xx.c
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/: qf_pkg.h
    ../../../../../src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
  group QP_port
    ../../../../../ports/arm-cm/qxk/iar/: qxk_port.c
  group QS
    ../../../../../src/qs/: qs.c qs_fp.c qs_rx.c
    ../../../../../src/: qs_pkg.h
  group STM32L5xx_HAL_Driver
    ../../../../../3rd_party/STM32CubeL5/Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_exti.c stm32l5xx_hal_gpio.c stm32l5xx_hal_icache.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
