# IAR project dpp-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S811; STACK_SIZE=800
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; display; $_QPC_$\include; $_QPC_$\ports\arm-cm\qk\iar; $_QPC_$\ports\arm-cm\cmsis
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qk.bin
  ILINK.IlinkOutputFile: dpp-qk.out
  ILINK.IlinkIcfFile: lm3s811.icf
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm-cm\qk\iar\dbg\libqp_cortex-m3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; NDEBUG; STACK_SIZE=600
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm-cm\qk\iar\rel\libqp_cortex-m3.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; Q_SPY; STACK_SIZE=600
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm-cm\qk\iar\spy\libqp_cortex-m3.a
  group display
    display/: display96x16x1.c display96x16x1.h
  group Source
    ./: bsp.c bsp.h dpp.h lm3s_config.h main.c philo.c startup_ewarm.c system_lm3s.c system_lm3s.h table.c
