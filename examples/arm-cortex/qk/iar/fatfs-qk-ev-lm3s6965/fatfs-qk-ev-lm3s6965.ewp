# IAR project fatfs-qk-ev-lm3s6965.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S6965; STACK_SIZE=1500
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; $_QPC_$\include; $_QPC_$\ports\arm-cortex\qk\iar; cmsis
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..; ..\..\..\third_party\lwip-1.3.0\apps; ..\..\..\third_party\lwip-1.3.0\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.0\src\include; ..\..\..\third_party\lwip-1.3.0\src\include\ipv4; ..\..\..\third_party
  OBJCOPY.OOCOutputFile: fatfs-qk-ev-lm3s6965.bin
  ILINK.IlinkOutputFile: lwip-qk-ev-lm3s6965.out
  ILINK.IlinkIcfFile: lm3s6965.icf
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm-cortex\qk\iar\dbg\libqep_cortex-m3.a; $_QPC_$\ports\arm-cortex\qk\iar\dbg\libqf_cortex-m3.a; $_QPC_$\ports\arm-cortex\qk\iar\dbg\libqk_cortex-m3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S6965; NDEBUG; STACK_SIZE=1500
  ICCARM.CCIncludePath2: .; $_QPC_$\include; $_QPC_$\ports\arm-cortex\qk\iar; cmsis; webserver; lwip_port; ..\..\..\..\..\..\lwip-1.4.0\ports\stellaris\include; ..\..\..\..\..\..\lwip-1.4.0\src\include; ..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4; ..\..\..\..\..\..\lwip-1.4.0\src
  OBJCOPY.OOCOutputFile: lwip-qk-ev-lm3s6965.bin
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm-cortex\qk\iar\rel\libqep_cortex-m3.a; $_QPC_$\ports\arm-cortex\qk\iar\rel\libqf_cortex-m3.a; $_QPC_$\ports\arm-cortex\qk\iar\rel\libqk_cortex-m3.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S6965; Q_SPY; STACK_SIZE=1500
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: lwip-qk-ev-lm3s6965.bin
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm-cortex\qk\iar\spy\libqep_cortex-m3.a; $_QPC_$\ports\arm-cortex\qk\iar\spy\libqf_cortex-m3.a; $_QPC_$\ports\arm-cortex\qk\iar\spy\libqk_cortex-m3.a; $_QPC_$\ports\arm-cortex\qk\iar\spy\libqs_cortex-m3.a
  group CMSIS
    cmsis/: core_cm3.h lm3s_cmsis.h startup_ewarm.c system_lm3s.c system_lm3s.h
  group Source
    ./: bsp.c bsp.h fatfsmgr.c fatfsmgr.h lm3s_config.h main.c
