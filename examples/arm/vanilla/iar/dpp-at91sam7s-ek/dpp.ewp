# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $_QPC_$\include; $_QPC_$\ports\arm\vanilla\iar; $TOOLKIT_DIR$\inc\atmel
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp.bin
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: at91SAM7S64.icf
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm\vanilla\iar\dbg\libqp_ARM7TDMI.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; NDEBUG
  ILINK.IlinkIcfFile: at91SAM7S64.icf
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm\vanilla\iar\rel\libqp_ARM7TDMI.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; Q_SPY
  ILINK.IlinkIcfFile: at91SAM7S64.icf
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm\vanilla\iar\spy\libqp_ARM7TDMI.a
  group Active Objects
    ./: dpp.h philo.c table.c
  group BSP
    ./: at91mc_cstartup.s bsp.c bsp.h main.c
