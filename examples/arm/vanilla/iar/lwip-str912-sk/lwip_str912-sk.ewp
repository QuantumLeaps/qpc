# IAR project lwip_str912-sk.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912F ST STR912F
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm\vanilla\iar; webserver; lwip_port; ..\..\..\..\..\..\lwip-1.3.0\ports\stellaris\include; ..\..\..\..\..\..\lwip-1.3.0\src\include; ..\..\..\..\..\..\lwip-1.3.0\src\include\ipv4; ..\..\..\..\..\..\lwip-1.3.0\src; STR91xlibrary\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: __REMAP_PREEMPTIVE_TICK_FUNC_
  AARM.AUserIncludes: ..\..\Source\portable\IAR\STR91x
  ILINK.IlinkOutputFile: lwip_str912-sk.out
  ILINK.IlinkIcfFile: STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: .; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm\vanilla\iar; STR91xlibrary\include
  ICCARM.CCOptStrategy: 0
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  group Application
    ./: dpp.h lwipmgr.c philo.c table.c
  group BSP
    ./: 91x_conf.h 91x_init.s 91x_it.c 91x_vect_qp.s bsp.c bsp.h main.c
    STR91xlibrary/source/: drv_hd44780.c drv_hd44780_l.c
  group lwIP
    lwip_port/netif/: eth_driver.c
    webserver/: fs.c httpd.c
    ./: lwip.c
  group QP-Debug
    ../../../../../ports/arm/vanilla/iar/dbg/: qep_ARM966E-S.a qf_ARM966E-S.a
  group QP-Release
    ../../../../../ports/arm/vanilla/iar/rel/: qep_ARM966E-S.a qf_ARM966E-S.a
  group QP-Spy
    ../../../../../ports/arm/vanilla/iar/spy/: qep_ARM966E-S.a qf_ARM966E-S.a qs_ARM966E-S.a
  group STR91xlibrary
    STR91xlibrary/source/: 91x_enet.c 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_scu.c 91x_tim.c 91x_uart.c 91x_wdg.c
    ./: 91x_vic_qp.c
