# Keil uVision project dpp.uvprojx, settings and files
target dpp-dbg (ARM-ADS)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dpp
  AfterMake: fromelf --bin --output .\dbg\dpp.bin .\dbg\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..;..\..\..\..\include;..\..\..\..\source;..\..\..\..\ports\cmsis-rtx;..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\3rd_party\CMSIS-RTX\INC; ..\..\..\..\3rd_party\nucleo-l152re
  asm define: Stack_Size=512 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --entry Reset_Handler
  group Application
    ../: bsp.c bsp.h dpp.h main.c philo.c README.txt table.c RTX_Conf_CM.c
  group nucleo-l152re
    ../../../../3rd_party/nucleo-l152re/: stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
    ../../../../3rd_party/nucleo-l152re/arm/: startup_stm32l1xx.s
  group QP
    ../../../../source/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_pkg.h qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
  group QP_port
    ../../../../ports/cmsis-rtx/: qep_port.h qf_port.c qf_port.h qs_port.h
  group QS
    ../../../../source/: qs.c qs_64bit.c qs_fp.c qs_pkg.h
  group CMSIS-RTX
    ../../../../3rd_party/CMSIS-RTX/LIB/ARM/: RTX_CM3.lib
target dpp-rel (ARM-ADS)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: dpp
  AfterMake: fromelf --bin --output .\rel\dpp.bin .\rel\dpp.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=512 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --entry Reset_Handler
target dpp-spy (ARM-ADS)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: dpp
  AfterMake: fromelf --bin --output .\spy\dpp.bin .\spy\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --entry Reset_Handler
