# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H743xx; USE_HAL_DRIVER; USE_STM32H7XX_NUCLEO_144
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; SEGGER; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\ports\embos; ..\..\..\..\..\3rd_party\embOS-iar\Start\Inc; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\STM32CubeH7\Drivers\CMSIS\Device\ST\STM32H7xx/Include; ..\..\..\..\..\3rd_party\STM32CubeH7\Drivers\BSP\STM32H7xx_Nucleo_144; ..\..\..\..\..\3rd_party\STM32CubeH7\Drivers\STM32H7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: dpp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32H743xx; USE_HAL_DRIVER; USE_STM32H7XX_NUCLEO_144
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; QF_ON_CONTEXT_SW; STM32H743xx; USE_HAL_DRIVER; USE_STM32H7XX_NUCLEO_144
  group Application
    ../: bsp.c main.c philo.c table.c
    ../../: dpp.h
  group embOS
    ../../../../../3rd_party/embOS-iar/Start/Lib/: os7m_tlv_r.a
  group nucleo-h743zi
    ../../../../../3rd_party/STM32CubeH7/nucleo-h743zi/iar/: startup_stm32h743xx.s
    ../: stm32h7xx_hal_conf.h stm32h7xx_hal_msp.c
    ../../../../../3rd_party/STM32CubeH7/Drivers/BSP/STM32H7xx_Nucleo_144/: stm32h7xx_nucleo_144.c
    ../../../../../3rd_party/STM32CubeH7/Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/: qf_pkg.h
  group QP_port
    ../../../../../ports/embos/: qep_port.h qf_port.c qf_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.c qs_fp.c qs_rx.c qstamp.c
    ../../../../../src/: qs_pkg.h
  group Setup
    Setup/: JLINKMEM_Process.c OS_Error.c RTOSInit_STM32H7xx.c
  group STM32H7xx_HAL_Driver
    ../../../../../3rd_party/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c
