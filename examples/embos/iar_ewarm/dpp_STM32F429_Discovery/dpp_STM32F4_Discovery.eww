<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\dpp_STM32F4_Discovery.ewp</path>
  </project>
  <batchBuild/>
</workspace>


