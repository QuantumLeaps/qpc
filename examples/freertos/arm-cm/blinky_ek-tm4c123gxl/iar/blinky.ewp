# IAR project blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __FPU_PRESENT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\include; ..\..\..\..\..\source; ..\..\..\..\..\ports\freertos\arm-cm\iar; ..\..\..\..\..\3rd_party\ek-tm4c123gxl; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\FreeRTOS\Source\include; ..\..\..\..\..\3rd_party\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..\..\ports\freertos\arm-cm\iar
  OBJCOPY.OOCOutputFile: blinky.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: blinky.out
  ILINK.IlinkIcfFile: blinky.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __FPU_PRESENT
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; __FPU_PRESENT
  group Application
    ../: blinky.c blinky.h bsp.c bsp.h main.c
    ../../../../../include/: qstamp.c
  group ek-tm4c123gxl
    ../../../../../3rd_party/ek-tm4c123gxl/: gpio.h rom.h sysctl.h system_TM4C123GH6PM.c system_TM4C123GH6PM.h TM4C123GH6PM.h
    ../../../../../3rd_party/ek-tm4c123gxl/iar/: startup_TM4C123GH6PM.s
  group FreeRTOS
    ../: FreeRTOSConfig.h
    ../../../../../3rd_party/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../../../../../3rd_party/FreeRTOS/Source/: list.c tasks.c
    ../../../../../3rd_party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group QP
    ../../../../../source/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_pkg.h qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
  group QP_port
    ../../../../../ports/freertos/arm-cm/iar/: qep_port.h qf_int_config.h qf_port.c qf_port.h qs_port.h
  group QS
    ../../../../../source/: qs.c qs_64bit.c qs_fp.c qs_pkg.h
