# Keil uVision project dpp.uvprojx, settings and files
target dpp-dbg (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.6.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: dpp
  BeforeMake: cmd /c "if exist .\dbg\qstamp.o del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp.bin .\dbg\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __FPU_PRESENT
  c include: ..;..\..\..\..\..\include;..\..\..\..\..\src;..\..\..\..\..\ports\freertos;..\..\..\..\..\3rd_party\FreeRTOS\Source\include;..\..\..\..\..\3rd_party\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\stm32f7-discovery;..\..\..\..\..\3rd_party\stm32f7-discovery\Drivers\BSP\STM32746G-Discovery;..\..\..\..\..\3rd_party\stm32f7-discovery\Drivers\STM32F7xx_HAL_Driver\Inc
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.c main.c philo.c table.c
    ../../../../../include/: qstamp.c
  group stm32f7-discovery
    ../: stm32f7xx_hal_msp.c
    ../../../../../3rd_party/stm32f7-discovery/arm/: startup_stm32f746xx.s
    ../../../../../3rd_party/stm32f7-discovery/: stm32f7xx.h stm32f746xx.h system_stm32f7xx.h system_stm32f7xx.c
    ../../../../../3rd_party/stm32f7-discovery/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.h stm32746g_discovery.c
  group STM32F7xx_HAL_Driver
    ../../../../../3rd_party/stm32f7-discovery/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c.c
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
  group QP_port
    ../../../../../ports/freertos/: qep_port.h qf_port.c qf_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c
  group FreeRTOS
    ../../../../../3rd_party/FreeRTOS/Source/: tasks.c list.c
    ../../../../../3rd_party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c portmacro.h
target dbg-rel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.6.0
  cpu: as above
  output: dpp
  BeforeMake: cmd /c "if exist .\rel\qstamp.o del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp.bin .\rel\dpp.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: NDEBUG __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
target dbg-spy (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.6.0
  cpu: as above
  output: dpp
  BeforeMake: cmd /c "if exist .\spy\qstamp.o del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp.bin .\spy\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
