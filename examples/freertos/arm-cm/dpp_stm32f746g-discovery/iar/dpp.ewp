# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\freertos; ..\..\..\..\..\3rd_party\FreeRTOS\Source\include; ..\..\..\..\..\3rd_party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\stm32f7-discovery; ..\..\..\..\..\3rd_party\stm32f7-discovery\Drivers\BSP\STM32746G-Discovery; ..\..\..\..\..\3rd_party\stm32f7-discovery\Drivers\STM32F7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: dpp.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: dpp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F746xx
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; STM32F746xx
  group Application
    ../: bsp.c dpp.h FreeRTOSConfig.h main.c philo.c table.c
    ../../: bsp.h dpp.h
    ../../../../../include/: qstamp.c
  group FreeRTOS
    ../../../../../3rd_party/FreeRTOS/Source/: list.c tasks.c
    ../../../../../3rd_party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/: qf_pkg.h
  group QP_port
    ../../../../../ports/freertos/: qep_port.h qf_port.c qf_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.c qs_fp.c qs_rx.c
    ../../../../../src/: qs_pkg.h
  group stm32f7-discovery
    ../../../../../3rd_party/stm32f7-discovery/iar/: startup_stm32f746xx.s
    ../../../../../3rd_party/stm32f7-discovery/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery.h
    ../: stm32f7xx_hal_msp.c
    ../../../../../3rd_party/stm32f7-discovery/: system_stm32f7xx.c
  group STM32F7xx_HAL_Driver
    ../../../../../3rd_party/stm32f7-discovery/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c
