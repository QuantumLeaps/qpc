# IAR project game.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S811; STACK_SIZE=600
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; $_QPC_$\include; $_QPC_$\ports\freertos; $_QPC_$\ports\arm-cm\cmsis; $_FREERTOS_$\FreeRTOS\Source\include; $_FREERTOS_$\FreeRTOS\Source\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: game.bin
  ILINK.IlinkOutputFile: game.out
  ILINK.IlinkIcfFile: game.icf
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\freertos\iar\dbg\libqp_cortex-m3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; NDEBUG; STACK_SIZE=600
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\freertos\iar\rel\libqp_cortex-m3.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; Q_SPY; STACK_SIZE=600
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\freertos\iar\spy\libqp_cortex-m3.a
  group (top)
    ./: startup_lm3s.c system_lm3s.c
  group FreeRTOS
    ./: FreeRTOSConfig.h
    $_FREERTOS_$/FreeRTOS/Source/portable/MemMang/: heap_1.c
    $_FREERTOS_$/FreeRTOS/Source/: list.c tasks.c
    $_FREERTOS_$/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group Source
    ./: bsp.c bsp.h display96x16x1.c display96x16x1.h game.h lm3s_cmsis.h main.c mine1.c mine2.c missile.c ship.c tunnel.c
