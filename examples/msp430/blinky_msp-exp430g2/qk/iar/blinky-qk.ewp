# IAR project blinky-qk.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa50
  ICC430.newCCIncludePaths: .; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\source; ..\..\..\..\..\ports\msp430\qk\iar
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430g2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
configuration Spy (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: Q_SPY
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  group Application
    ../../: blinky.c blinky.h bsp.h main.c
    ../: bsp.c
    ../../../../../include/: qstamp.c
  group QP
    ../../../../../source/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_pkg.h qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c qk.c qk_mutex.c qk_pkg.h
  group QP_port
    ../../../../../ports/msp430/qk/ccs/: qep_port.h qf_port.h qk_port.c qk_port.h qs_port.h
  group QS
    ../../../../../source/: qs.c qs_fp.c qs_pkg.h qs_rx.c
