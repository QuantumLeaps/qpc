# IAR project dpp.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 64
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: ; $_QPC_$\include\; $_QPC_$\ports\msp430\vanilla\iar\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 2
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: $_QPC_$\ports\msp430\vanilla\iar\dbg\libqp.r43
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.IccLang: 0
  XLINK.XExtraOptions: $_QPC_$\ports\msp430\vanilla\iar\rel\libqp.r43
configuration Spy (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: Q_SPY
  XLINK.XExtraOptions: $_QPC_$\ports\msp430\vanilla\iar\spy\libqp.r43
  group (top)
    ./: bsp.c main.c philo.c table.c
  group Header files
    ./: bsp.h dpp.h
