# IAR project efm32-slstk3401a.ewp, settings and files
configuration QUTest (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: Q_SPY; Q_UTEST; EFM32PG1B200F256GM48
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\include; ..\..\..\src; ..\..\..\ports\arm-cm\qutest; ..\..\..\3rd_party\CMSIS\Include; ..\..\..\3rd_party\efm32pg1b
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: efm32-slstk3401a.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: efm32-slstk3401a.out
  ILINK.IlinkIcfFile: ..\efm32-slstk3401a\test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: bsp.c bsp.h dpp.h main.c philo.c table.c test_dpp.c
    ../../../include/: qstamp.c
  group efm32pg1b
    ../../../3rd_party/efm32pg1b/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_system.c em_usart.c system_efm32pg1b.c
    ../../../3rd_party/efm32pg1b/iar/: startup_efm32pg1b.s
  group QP
    ../../../src/: qep_hsm.c
    ../../../src/qf/: qep_msm.c qf_act.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c
    ../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qutest.c
  group QP_port
    ../efm32-slstk3401a/: qutest_port.c
