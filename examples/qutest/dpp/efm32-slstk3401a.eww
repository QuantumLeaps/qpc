<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\efm32-slstk3401a.ewp</path>
  </project>
  <batchBuild/>
</workspace>


