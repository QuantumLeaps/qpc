# IAR project lwip-qk.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0
  General.IStackSize: 0x400
  General.HeapSize: 0
  ICCRX.CCDefines: DEBUG
  ICCRX.CCDiagSuppress: Pa050
  ICCRX.CCIncludePath2: .; Glyph; webserver; lwip_port; $_QPC_$\ports\rx\qk\iar; $_QPC_$\include; \software\lwip-1.4.0\src\include; \software\lwip-1.4.0\src\include\ipv4; \software\lwip-1.4.0\src
  ICCRX.IccExtraOptions: --save_acc
  ICCRX.IccLang: 2
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: lwip-qk.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\rx\qk\iar\dbg\libqep_RX600.a; $_QPC_$\ports\rx\qk\iar\dbg\libqf_RX600.a; $_QPC_$\ports\rx\qk\iar\dbg\libqk_RX600.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX, debug)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  ICCRX.CCIncludePath2: $_QPC_$\ports\rx\qk\iar; $_QPC_$\include
  OBJCOPY.OOCOutputFile: lwip-qk.srec
configuration Spy (RX, debug)
  as the first configuration, except:
  ICCRX.CCDefines: Q_SPY
  ICCRX.CCIncludePath2: $_QPC_$\ports\rx\qk\iar; $_QPC_$\include
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\rx\qk\iar\spy\libqep_RX600.a; $_QPC_$\ports\rx\qk\iar\spy\libqf_RX600.a; $_QPC_$\ports\rx\qk\iar\spy\libqk_RX600.a; $_QPC_$\ports\rx\qk\iar\spy\libqs_RX600.a
  group (top)
    ./: bsp.c bsp.h dpp.h lwipmgr.c lwipopts.h main.c philo.c table.c
  group lwip
    lwip_port/netif/: eth_driver.c phy.c phy.h
    webserver/: fs.c httpd.c
    ./: lwip.c lwip.h
