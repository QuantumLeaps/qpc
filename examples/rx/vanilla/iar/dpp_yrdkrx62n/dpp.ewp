# IAR project dpp.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0
  General.IStackSize: 0x400
  General.HeapSize: 0
  ICCRX.CCDefines: DEBUG
  ICCRX.CCDiagSuppress: Pa050
  ICCRX.CCIncludePath2: $_QPC_$\ports\rx\vanilla\iar; $_QPC_$\include
  ICCRX.IccExtraOptions: --diag_suppress Pa050
  ICCRX.IccLang: 2
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\rx\vanilla\iar\dbg\libqep_RX600.a; $_QPC_$\ports\rx\vanilla\iar\dbg\libqf_RX600.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX, debug)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: dpp.srec
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\rx\vanilla\iar\rel\libqep_RX600.a; $_QPC_$\ports\rx\vanilla\iar\rel\libqf_RX600.a
configuration Spy (RX, debug)
  as the first configuration, except:
  ICCRX.CCDefines: Q_SPY
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\rx\vanilla\iar\spy\libqep_RX600.a; $_QPC_$\ports\rx\vanilla\iar\spy\libqf_RX600.a; $_QPC_$\ports\rx\vanilla\iar\spy\libqs_RX600.a
  group (top)
    ./: bsp.c bsp.h dpp.h main.c philo.c table.c
