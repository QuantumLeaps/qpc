# Keil uVision project efm32pg1b.uvprojx, settings and files
target qutest (6160000::V6.16::ARMCLANG)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFM32PG1B_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_fixture
  BeforeMake: cmd /c "del .\uvision_emf32\qstamp.o"
  AfterMake: fromelf --bin --output .\uvision_emf32\test_fixture.bin .\uvision_emf32\test_fixture.axf
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY,Q_UTEST=0,QF_ON_CONTEXT_SW
  c include: .;..\..\..\include;..\..\..\ports\arm-cm\qk\armclang;..\..\..\3rd_party\CMSIS\Include;..\..\..\3rd_party\efm32pg1b
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ./: bsp.h test_sched.c bsp_efm32pg1b.c
  group efm32pg1b
    ../../../3rd_party/efm32pg1b/arm/: startup_efm32pg1b.s
    ../../../3rd_party/efm32pg1b/: em_cmu.c em_emu.c em_gpio.c system_efm32pg1b.c em_system.c em_usart.c
  group QP
    ../../../src/qf/: qep_hsm.c qep_msm.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qf/: qf_act.c
    ../../../src/qk/: qk.c
  group QP_port
    ../../../ports/arm-cm/qxk/armclang/: qp_port.h qs_port.h
    ../../../ports/arm-cm/qk/armclang/: qk_port.c
    ../../../3rd_party/efm32pg1b/qutest/: qutest_port.c
  group QS
    ../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qutest.c qstamp.c
