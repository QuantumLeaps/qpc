# Keil uVision project nucleo-c031c6.uvprojx, settings and files
target qutest (6160000::V6.16::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test
  BeforeMake: cmd /c "del .\uvision_nucleo-c031c6\qstamp.o"
  AfterMake: fromelf --bin --output .\uvision_nucleo-c031c6\test.bin .\uvision_nucleo-c031c6\test.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY, Q_UTEST=0,QK_USE_IRQ_HANDLER=Reserved1_IRQHandler,QK_USE_IRQ_NUM=1,QF_ON_CONTEXT_SW
  c include: .;..\..\..\include;..\..\..\ports\arm-cm\qk\armclang;..\..\..\3rd_party\CMSIS\Include,..\..\..\3rd_party\nucleo-c031c6
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --entry Reset_Handler
  group test
    ./: bsp.h test_sched.c bsp_nucleo-c031c6.c
  group nucleo-c031c6
    ../../../3rd_party/nucleo-c031c6/arm/: startup_stm32c031xx.s
    ../../../3rd_party/nucleo-c031c6/: stm32c031xx.h system_stm32c0xx.c system_stm32c0xx.h
    ../../../3rd_party/nucleo-c031c6/qutest/: qutest_port.c
  group QP
    ../../../src/qf/: qep_hsm.c qep_msm.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qf/: qf_act.c
    ../../../src/qk/: qk.c
  group QP_port
    ../../../ports/arm-cm/qk/armclang/: qep_port.h qf_port.h qk_port.c qk_port.h qs_port.h
  group QS
    ../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qstamp.c qutest.c
