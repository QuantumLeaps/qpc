# Keil uVision project nucleo-l053r8.uvprojx, settings and files
target qutest (6160000::V6.16::ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test
  BeforeMake: cmd /c "del .\uvision_nucleo-l053r8\qstamp.o"
  AfterMake: fromelf --bin --output .\uvision_nucleo-l053r8\test.bin .\uvision_nucleo-l053r8\test.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY, Q_UTEST=0,QK_USE_IRQ_HANDLER=LCD_IRQHandler,QK_USE_IRQ_NUM=30,QF_ON_CONTEXT_SW
  c include: .;..\..\..\include;..\..\..\ports\arm-cm\qk\armclang;..\..\..\3rd_party\CMSIS\Include,..\..\..\3rd_party\nucleo-l053r8
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group test
    ./: bsp.h test_sched.c bsp_nucleo-l053r8.c
  group nucleo-l053r8
    ../../../3rd_party/nucleo-l053r8/: stm32l0xx.h stm32l053xx.h system_stm32l0xx.c system_stm32l0xx.h
    ../../../3rd_party/nucleo-l053r8/arm/: startup_stm32l053xx.s
    ../../../3rd_party/nucleo-l053r8/qutest/: qutest_port.c
  group QP
    ../../../src/qf/: qep_hsm.c qep_msm.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qf/: qf_act.c
    ../../../src/qk/: qk.c
  group QP_port
    ../../../ports/arm-cm/qk/armclang/: qp_port.h qk_port.c qs_port.h
  group QS
    ../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qstamp.c qutest.c
